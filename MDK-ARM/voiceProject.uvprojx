# Keil uVision project voiceProject.uvprojx, settings and files
target voice-MxxxA (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HK32F0301MF6N7A HK_MicroChip
  pack: HKMicroChip.HK32F030xMxx_DFP.1.0.17
  cpu: IRAM(0x20000000,0x1000) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: D7VoiceMxxxA
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: HK32F0301MG6P7A,HK32F0301MXXA,USE_HK32F0301MG6P7A_EVAL,USE_DEFAULT_TIMEOUT_CALLBACK
  c include: ..\Libraries\CMSIS\CM0\Core;..\Libraries\CMSIS\HK32F030xMxxA\Include;..\Libraries\CMSIS\HK32F030xMxxA\Source\ARM;..\Libraries\CMSIS\HK32F030xMxxA\Source;..\Libraries\CMSIS\HK32F030xMxxA\Include;..\Libraries\HK32F030xMxxA_StdPeriph_Driver\inc;..\Libraries\HK32F030xMxxA_StdPeriph_Driver\src;..\inc;..\src;..\Boards;..\userLib\src;..\userLib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../Libraries/CMSIS/HK32F030xMxxA/Source/ARM/: KEIL_Startup_hk32f030xmxxa.s
    ../Libraries/CMSIS/HK32F030xMxxA/Source/: system_hk32f030xmxxa.c
  group User
    ../src/: hk32f030xmxxa_it.c main.c
  group StdPeriph_Driver
    ../Libraries/HK32F030xMxxA_StdPeriph_Driver/src/: hk32f030xmxxa_adc.c hk32f030xmxxa_awut.c hk32f030xmxxa_beep.c hk32f030xmxxa_crc.c hk32f030xmxxa_dbgmcu.c hk32f030xmxxa_exti.c hk32f030xmxxa_flash.c hk32f030xmxxa_gpio.c hk32f030xmxxa_i2c.c hk32f030xmxxa_iwdg.c hk32f030xmxxa_misc.c hk32f030xmxxa_pwr.c hk32f030xmxxa_rcc.c hk32f030xmxxa_spi.c hk32f030xmxxa_syscfg.c hk32f030xmxxa_tim.c hk32f030xmxxa_usart.c hk32f030xmxxa_wwdg.c
  group Boards
    ../userLib/src/: l_timer.c
    ../Boards/: l_uart.c l_gpio.c
  group userLib
    ../userLib/src/: f_idle.c f_init.c l_arch.c l_sysProcess.c l_u8FIFO.c l_rs485.c l_jsonTL.c l_actionFIFO.c l_flash.c
